options:
  parameters:
    comment: 'Stage 1-3 coherent FX engine only. RX0=Antenna 0 / 2.4 m, RX1=Antenna 1 / 1.7 m. Cross-spectrum convention: C01[k] = X0[k] * conj(X1[k]). High-side LNB sky axis uses x_start=lnb_lo-(if_cf-samp_rate/2), x_step=-samp_rate/fft_size.'
    description: Minimal two-channel B210 FX correlator commissioning flowgraph.
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: fx_interferometer_v1_stage1_3
    output_language: python
    title: FX Interferometer V1 Stage 1-3
  states: {}

blocks:
- name: accum_frames
  id: variable
  parameters:
    comment: 'At defaults: round(7500*0.1) = 750 FFT vectors.'
    value: int(round(fft_rate*accum_time))
  states: {}
- name: accum_time
  id: variable
  parameters:
    comment: First-stage accumulation time in seconds.
    value: '0.01'
  states: {}
- name: fft_rate
  id: variable
  parameters:
    comment: 'At defaults: 30.72e6/4096 = 7500 FFT vectors/s.'
    value: samp_rate/fft_size
  states: {}
- name: fft_size
  id: variable
  parameters:
    comment: Default FFT length. Stage 1-3 default is 4096.
    value: '4096'
  states: {}
- name: gain0
  id: variable
  parameters:
    comment: RX0 / antenna 0 / 2.4 m commissioning gain, dB.
    value: '40'
  states: {}
- name: gain1
  id: variable
  parameters:
    comment: RX1 / antenna 1 / 1.7 m commissioning gain, dB.
    value: '40'
  states: {}
- name: if_cf
  id: variable
  parameters:
    comment: 'Nominal B210 IF centre frequency: lnb_lo - sky_cf = 1.150 GHz.'
    value: lnb_lo-sky_cf
  states: {}
- name: lnb_lo
  id: variable
  parameters:
    comment: High-side LNB local oscillator, Hz.
    value: 5.950e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Target B210 sample rate per RX channel.
    value: 30.72e6
  states: {}
- name: sky_axis_start
  id: variable
  parameters:
    comment: Left edge of shifted FFT display in sky Hz. High-side conversion reverses IF frequency.
    value: lnb_lo-(if_cf-samp_rate/2)
  states: {}
- name: sky_axis_step
  id: variable
  parameters:
    comment: Negative display bin step maps increasing IF bins to decreasing sky frequency.
    value: '-samp_rate/fft_size'
  states: {}
- name: sky_cf
  id: variable
  parameters:
    comment: Nominal astronomical sky centre frequency, Hz.
    value: 4.800e9
  states: {}
- name: auto_spectra_sink
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: 'RX0 P0: antenna 0 / 2.4 m'
    label2: 'RX1 P1: antenna 1 / 1.7 m'
    nconnections: '2'
    showports: 'True'
    vlen: fft_size
    x_axis_label: Sky frequency (GHz)
    x_start: sky_axis_start/1e9
    x_step: sky_axis_step/1e9
    y_axis_label: Relative power (dB)
  states: {}
- name: cross_accum
  id: blocks_integrate_xx
  parameters:
    decim: accum_frames
    type: complex
    vlen: fft_size
  states: {}
- name: cross_mag
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: cross_mag_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
    vlen: fft_size
  states: {}
- name: cross_mag_sink
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: '|C01|, X0 * conj(X1)'
    showports: 'True'
    vlen: fft_size
    x_axis_label: Sky frequency (GHz)
    x_start: sky_axis_start/1e9
    x_step: sky_axis_step/1e9
    y_axis_label: Relative cross magnitude (dB)
  states: {}
- name: cross_multiply_conjugate
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: fft_size
  states: {}
- name: cross_phase_deg
  id: blocks_multiply_const_vxx
  parameters:
    const: '[57.29577951308232]*fft_size'
    type: float
    vlen: fft_size
  states: {}
- name: cross_phase_rad
  id: blocks_complex_to_arg
  parameters:
    vlen: fft_size
  states: {}
- name: cross_phase_sink
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    label1: arg(C01), X0 * conj(X1)
    showports: 'True'
    vlen: fft_size
    x_axis_label: Sky frequency (GHz)
    x_start: sky_axis_start/1e9
    x_step: sky_axis_step/1e9
    y_axis_label: Cross phase (deg)
    ymax: '180'
    ymin: '-180'
  states: {}
- name: delay_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    comment: Stage 4 estimated differential delay from phase slope.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Differential Delay
    max: '100'
    min: '-100'
    name: '"Differential Delay (ns)"'
    type: float
    unit1: ns
    update_time: '0.25'
  states: {}
- name: phase_fit_rms_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    comment: Stage 4 RMS residual of linear phase fit.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Phase Fit RMS
    max: '180'
    min: '0'
    name: '"Phase Fit RMS (deg)"'
    type: float
    unit1: deg
    update_time: '0.25'
  states: {}
- name: phase_slope_delay_estimator
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Stage 4 phase-slope / differential-delay estimator.

          Fits unwrapped C01 phase against increasing B210 baseband/IF
          frequency. Cross-spectrum convention is C01 = X0 * conj(X1).
          Provisional sign convention: positive RX1 delay relative to RX0
          should produce positive phase slope versus increasing IF/baseband
          frequency and positive reported differential delay.
          """

          def __init__(self, fft_size=4096, samp_rate=30.72e6):
              self.fft_size = int(fft_size)
              self.samp_rate = float(samp_rate)
              gr.sync_block.__init__(
                  self,
                  name='Phase Slope / Delay Estimator',
                  in_sig=[(np.complex64, self.fft_size)],
                  out_sig=[np.float32, np.float32, np.float32],
              )
              self._f = (
                  (np.arange(self.fft_size, dtype=np.float64) - self.fft_size / 2.0)
                  * self.samp_rate
                  / self.fft_size
              )

          def work(self, input_items, output_items):
              spectra = input_items[0]
              delay_ns = output_items[0]
              slope_deg_per_mhz = output_items[1]
              fit_rms_deg = output_items[2]

              for i, c01 in enumerate(spectra):
                  phase = np.angle(c01)
                  phase_unwrapped = np.unwrap(phase).astype(np.float64)
                  slope, intercept = np.polyfit(self._f, phase_unwrapped, 1)
                  phase_fit = slope * self._f + intercept
                  residual = phase_unwrapped - phase_fit

                  delay_ns[i] = np.float32((slope / (2.0 * np.pi)) * 1e9)
                  slope_deg_per_mhz[i] = np.float32(slope * (180.0 / np.pi) * 1e6)
                  fit_rms_deg[i] = np.float32(
                      np.sqrt(np.mean(residual * residual)) * (180.0 / np.pi)
                  )

              return len(spectra)
    comment: 'Stage 4 only: low-rate estimator after cross_accum. Fits against increasing baseband/IF frequency, not displayed sky frequency.'
    fft_size: fft_size
    samp_rate: samp_rate
  states: {}
- name: phase_slope_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    comment: Stage 4 phase slope in degrees per MHz.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Phase Slope
    max: '1000'
    min: '-1000'
    name: '"Phase Slope (deg/MHz)"'
    type: float
    unit1: deg/MHz
    update_time: '0.25'
  states: {}
- name: rx0_fft
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: rx0_mag2
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: rx0_power_accum
  id: blocks_integrate_xx
  parameters:
    decim: accum_frames
    type: float
    vlen: fft_size
  states: {}
- name: rx0_power_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: rx0_stream_to_vector
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: rx1_fft
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: rx1_mag2
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: rx1_power_accum
  id: blocks_integrate_xx
  parameters:
    decim: accum_frames
    type: float
    vlen: fft_size
  states: {}
- name: rx1_power_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: rx1_stream_to_vector
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    center_freq0: if_cf
    center_freq1: if_cf
    clock_rate: '0.0'
    clock_source0: external
    dev_addr: ''
    dev_args: '"num_recv_frames=256"'
    gain0: gain0
    gain1: gain1
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: sync
    time_source0: internal
    type: fc32
  states: {}

connections:
- [cross_accum, '0', cross_mag, '0']
- [cross_accum, '0', cross_phase_rad, '0']
- [cross_accum, '0', phase_slope_delay_estimator, '0']
- [cross_mag, '0', cross_mag_db, '0']
- [cross_mag_db, '0', cross_mag_sink, '0']
- [cross_multiply_conjugate, '0', cross_accum, '0']
- [cross_phase_deg, '0', cross_phase_sink, '0']
- [cross_phase_rad, '0', cross_phase_deg, '0']
- [phase_slope_delay_estimator, '0', delay_number_sink, '0']
- [phase_slope_delay_estimator, '1', phase_slope_number_sink, '0']
- [phase_slope_delay_estimator, '2', phase_fit_rms_number_sink, '0']
- [rx0_fft, '0', cross_multiply_conjugate, '0']
- [rx0_fft, '0', rx0_mag2, '0']
- [rx0_mag2, '0', rx0_power_accum, '0']
- [rx0_power_accum, '0', rx0_power_db, '0']
- [rx0_power_db, '0', auto_spectra_sink, '0']
- [rx0_stream_to_vector, '0', rx0_fft, '0']
- [rx1_fft, '0', cross_multiply_conjugate, '1']
- [rx1_fft, '0', rx1_mag2, '0']
- [rx1_mag2, '0', rx1_power_accum, '0']
- [rx1_power_accum, '0', rx1_power_db, '0']
- [rx1_power_db, '0', auto_spectra_sink, '1']
- [rx1_stream_to_vector, '0', rx1_fft, '0']
- [uhd_usrp_source_0, '0', rx0_stream_to_vector, '0']
- [uhd_usrp_source_0, '1', rx1_stream_to_vector, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
