options:
  parameters:
    comment: 'Stage 9 FX interferometer flowgraph. RX0=Antenna 0 / 2.4 m, RX1=Antenna 1 / 1.7 m. Cross-spectrum convention: C01[k] = X0[k] * conj(X1[k]). High-side LNB sky axis uses x_start=lnb_lo-(if_cf-samp_rate/2), x_step=-samp_rate/fft_size.'
    description: Minimal two-channel B210 FX correlator commissioning flowgraph.
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: fx_interferometer_v1_stage9
    output_language: python
    title: FX Interferometer V1 Stage 9
  states: {}

blocks:
- name: accum_frames
  id: variable
  parameters:
    comment: 'At defaults: round(7500*0.1) = 750 FFT vectors.'
    value: int(round(fft_rate*accum_time))
  states: {}
- name: accum_time
  id: variable
  parameters:
    comment: First-stage accumulation time in seconds.
    value: '0.1'
  states: {}
- name: fft_rate
  id: variable
  parameters:
    comment: 'At defaults: 30.72e6/4096 = 7500 FFT vectors/s.'
    value: samp_rate/fft_size
  states: {}
- name: fft_size
  id: variable
  parameters:
    comment: Default FFT length. Stage 1-3 default is 4096.
    value: '4096'
  states: {}
- name: phase_fit_edge_exclude_pct
  id: variable
  parameters:
    comment: Stage 4 phase fit edge exclusion percentage from each end of FFT spectrum.
    value: '7.5'
  states: {}
- name: delay_correction_enable
  id: variable_qtgui_chooser
  parameters:
    comment: 'Stage 7 runtime bypass: True applies frequency-domain delay-slope correction, False passes raw C01 through.'
    label: Delay Correction
    label0: Enabled
    label1: Bypass
    num_opts: '2'
    option0: 'True'
    option1: 'False'
    options: '[True, False]'
    orient: Qt.QHBoxLayout
    type: bool
    value: 'True'
  states: {}
- name: instrument_delay_ns
  id: variable_qtgui_entry
  parameters:
    comment: Stage 7 static instrumental delay, ns. Positive means RX1 electrically delayed relative to RX0.
    label: Instrument Delay (ns)
    type: string
    value: '0.0'
  states: {}
- name: visibility_edge_exclude_pct
  id: variable
  parameters:
    comment: Stage 8 broadband visibility edge exclusion percentage from each end of corrected spectrum.
    value: '20.0'
  states: {}
- name: visibility_rate
  id: variable
  parameters:
    comment: Stage 8 low-rate visibility sample rate after first-stage accumulation.
    value: fft_rate/accum_frames
  states: {}
- name: fringe_stop_enable
  id: variable_qtgui_chooser
  parameters:
    comment: 'Stage 8 runtime bypass: True applies centre-frequency geometric fringe stopping, False passes V_unstopped through.'
    label: Fringe Stop
    label0: Enabled
    label1: Bypass
    num_opts: '2'
    option0: 'True'
    option1: 'False'
    options: '[True, False]'
    orient: Qt.QHBoxLayout
    type: bool
    value: 'True'
  states: {}
- name: fringe_stop_sign
  id: variable_qtgui_chooser
  parameters:
    comment: Stage 8 commissioning sign control. Default Normal removes +phi_geo using exp(-j phi_geo).
    label: Fringe Stop Sign
    label0: Normal (-phi_geo)
    label1: Reverse test (+phi_geo)
    num_opts: '2'
    option0: '-1'
    option1: '1'
    options: '[-1, 1]'
    orient: Qt.QHBoxLayout
    type: int
    value: '-1'
  states: {}
- name: integration_time_index
  id: variable_qtgui_chooser
  parameters:
    comment: Stage 9 coherent integration selector index. integration_time_s maps this index to seconds.
    label: Coherent Integration
    label0: 0.1 s
    label1: 0.25 s
    label2: 0.5 s
    label3: 1 s
    label4: 2 s
    labels: '["5 s", "10 s", "20 s", "30 s", "60 s"]'
    num_opts: '10'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    options: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9]'
    orient: Qt.QHBoxLayout
    type: int
    value: '3'
  states: {}
- name: integration_time_s
  id: variable
  parameters:
    comment: Stage 9 requested coherent integration time in seconds, derived from the GUI selector.
    value: '[0.1, 0.25, 0.5, 1.0, 2.0, 5.0, 10.0, 20.0, 30.0, 60.0][integration_time_index]'
  states: {}
- name: phase_rate_fit_window_s
  id: variable
  parameters:
    comment: Stage 9 phase-stability advisor native phase-fit history window, seconds.
    value: '60.0'
  states: {}
- name: coherence_target_pct
  id: variable
  parameters:
    comment: Stage 9 rate-based coherence target percentage for recommended maximum integration.
    value: '95.0'
  states: {}
- name: gain0
  id: variable
  parameters:
    comment: RX0 / antenna 0 / 2.4 m commissioning gain, dB.
    value: '40'
  states: {}
- name: gain1
  id: variable
  parameters:
    comment: RX1 / antenna 1 / 1.7 m commissioning gain, dB.
    value: '40'
  states: {}
- name: if_cf
  id: variable
  parameters:
    comment: 'Nominal B210 IF centre frequency: lnb_lo - sky_cf = 1.150 GHz.'
    value: lnb_lo-sky_cf
  states: {}
- name: lnb_lo
  id: variable
  parameters:
    comment: High-side LNB local oscillator, Hz.
    value: 5.950e9
  states: {}
- name: manual_dec_deg
  id: variable_qtgui_entry
  parameters:
    comment: Stage 5 manual source ICRS declination, decimal degrees.
    label: Manual Dec (deg)
    type: string
    value: '-30.0'
  states: {}
- name: manual_ra_hours
  id: variable_qtgui_entry
  parameters:
    comment: Stage 5 manual source ICRS right ascension, decimal hours.
    label: Manual RA (h)
    type: string
    value: '5.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Target B210 sample rate per RX channel.
    value: 30.72e6
  states: {}
- name: site_height_m
  id: variable
  parameters:
    comment: Stage 5 observing site height above ellipsoid/metres, initial value.
    value: '70'
  states: {}
- name: site_lat_deg
  id: variable
  parameters:
    comment: Stage 5 observing site latitude, degrees north positive.
    value: '-32.724'
  states: {}
- name: site_lon_deg
  id: variable
  parameters:
    comment: Stage 5 observing site longitude, degrees east positive.
    value: '+152.130167'
  states: {}
- name: baseline_e_m
  id: variable
  parameters:
    comment: Stage 6 B01 = r1-r0 east component, metres.
    value: '-5.785'
  states: {}
- name: baseline_n_m
  id: variable
  parameters:
    comment: Stage 6 B01 = r1-r0 north component, metres. Current working N is astronomically refined.
    value: '+0.095'
  states: {}
- name: baseline_u_m
  id: variable
  parameters:
    comment: Stage 6 B01 = r1-r0 up component, metres.
    value: '+0.580'
  states: {}
- name: sky_axis_start
  id: variable
  parameters:
    comment: Left edge of shifted FFT display in sky Hz. High-side conversion reverses IF frequency.
    value: lnb_lo-(if_cf-samp_rate/2)
  states: {}
- name: sky_axis_step
  id: variable
  parameters:
    comment: Negative display bin step maps increasing IF bins to decreasing sky frequency.
    value: '-samp_rate/fft_size'
  states: {}
- name: sky_cf
  id: variable
  parameters:
    comment: Nominal astronomical sky centre frequency, Hz.
    value: 4.800e9
  states: {}
- name: source_mode
  id: variable_qtgui_chooser
  parameters:
    comment: 'Stage 5 source selector: 0=Sun, 1=Manual ICRS RA/Dec.'
    label: Source
    label0: Sun
    label1: Manual RA/Dec
    num_opts: '2'
    option0: '0'
    option1: '1'
    options: '[0, 1]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: astronomy_coordinate_engine
  id: epy_block
  parameters:
    _source_code: |
      import time

      import numpy as np
      from gnuradio import gr

      from astropy import units as u
      from astropy.coordinates import AltAz, EarthLocation, SkyCoord, TETE, get_sun
      from astropy.time import Time
      from astropy.utils import iers

      iers.conf.auto_download = False
      iers.conf.iers_degraded_accuracy = 'warn'


      class blk(gr.sync_block):
          """Stage 5 source/site/time astronomy-coordinate engine."""

          def __init__(
              self,
              fft_size=4096,
              site_lat_deg=-32.724,
              site_lon_deg=152.130167,
              site_height_m=70.0,
              source_mode=0,
              manual_ra_hours=5.0,
              manual_dec_deg=-30.0,
          ):
              self.fft_size = int(fft_size)
              self.site_lat_deg = float(site_lat_deg)
              self.site_lon_deg = float(site_lon_deg)
              self.site_height_m = float(site_height_m)
              self.source_mode = int(source_mode)
              self.manual_ra_hours = float(manual_ra_hours)
              self.manual_dec_deg = float(manual_dec_deg)
              self._last_update = 0.0
              self._cache = np.full(7, np.nan, dtype=np.float32)
              gr.sync_block.__init__(
                  self,
                  name='Astronomy Coordinate Engine',
                  in_sig=[(np.complex64, self.fft_size)],
                  out_sig=[
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                  ],
              )

          def _invalidate(self):
              self._last_update = 0.0

          def set_site_lat_deg(self, value):
              self.site_lat_deg = float(value)
              self._invalidate()

          def set_site_lon_deg(self, value):
              self.site_lon_deg = float(value)
              self._invalidate()

          def set_site_height_m(self, value):
              self.site_height_m = float(value)
              self._invalidate()

          def set_source_mode(self, value):
              self.source_mode = int(value)
              self._invalidate()

          def set_manual_ra_hours(self, value):
              self.manual_ra_hours = float(value)
              self._invalidate()

          def set_manual_dec_deg(self, value):
              self.manual_dec_deg = float(value)
              self._invalidate()

          def _compute(self):
              site_lat_deg = float(self.site_lat_deg)
              site_lon_deg = float(self.site_lon_deg)
              site_height_m = float(self.site_height_m)
              source_mode = int(self.source_mode)
              manual_ra_hours = float(self.manual_ra_hours)
              manual_dec_deg = float(self.manual_dec_deg)

              location = EarthLocation(
                  lat=site_lat_deg * u.deg,
                  lon=site_lon_deg * u.deg,
                  height=site_height_m * u.m,
              )
              obstime = Time.now()
              obstime.location = location

              if source_mode == 0:
                  source_coord = get_sun(obstime)
              else:
                  source_coord = SkyCoord(
                      ra=manual_ra_hours * u.hourangle,
                      dec=manual_dec_deg * u.deg,
                      frame='icrs',
                  )

              apparent = source_coord.transform_to(TETE(obstime=obstime, location=location))
              altaz = source_coord.transform_to(
                  AltAz(obstime=obstime, location=location, pressure=0 * u.hPa)
              )

              utc_dt = obstime.utc.datetime
              utc_hour = (
                  utc_dt.hour
                  + utc_dt.minute / 60.0
                  + (utc_dt.second + utc_dt.microsecond * 1e-6) / 3600.0
              )
              lmst_hour = (
                  obstime.sidereal_time('apparent', longitude=site_lon_deg * u.deg).hour
                  % 24.0
              )
              apparent_ra_hour = apparent.ra.hour % 24.0
              apparent_dec_deg = apparent.dec.deg
              ha_hour = ((lmst_hour - apparent_ra_hour + 12.0) % 24.0) - 12.0

              self._cache = np.array(
                  [
                      utc_hour,
                      lmst_hour,
                      ha_hour,
                      altaz.az.deg % 360.0,
                      altaz.alt.deg,
                      apparent_ra_hour,
                      apparent_dec_deg,
                  ],
                  dtype=np.float32,
              )
              self._last_update = time.monotonic()

          def work(self, input_items, output_items):
              nout = len(input_items[0])
              if nout == 0:
                  return 0

              if self._last_update == 0.0 or time.monotonic() - self._last_update >= 1.0:
                  try:
                      self._compute()
                  except Exception as exc:
                      print(f"Stage 5 astronomy error: {exc}", flush=True)
                      self._cache = np.full(7, np.nan, dtype=np.float32)
                      self._last_update = time.monotonic()

              for idx, value in enumerate(self._cache):
                  output_items[idx][:nout] = value

              return nout
    comment: 'Stage 5 only: low-rate Astropy source/site/time coordinates after cross_accum. Does not correct C01.'
    fft_size: fft_size
    manual_dec_deg: manual_dec_deg
    manual_ra_hours: manual_ra_hours
    site_height_m: site_height_m
    site_lat_deg: site_lat_deg
    site_lon_deg: site_lon_deg
    source_mode: source_mode
  states: {}
- name: astronomy_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    color2: ("blue", "red")
    color3: ("blue", "red")
    color4: ("blue", "red")
    color5: ("blue", "red")
    color6: ("blue", "red")
    color7: ("blue", "red")
    comment: Stage 5 astronomy/source numerical displays.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: UTC
    label2: LMST
    label3: Hour Angle
    label4: Azimuth
    label5: Elevation
    label6: Apparent RA
    label7: Apparent Dec
    max: '360'
    min: '-180'
    name: '"Astronomy / Source Coordinates"'
    nconnections: '7'
    type: float
    unit1: h
    unit2: h
    unit3: h
    unit4: deg
    unit5: deg
    unit6: h
    unit7: deg
    update_time: '0.5'
  states: {}
- name: baseline_geometry_engine
  id: epy_block
  parameters:
    _source_code: |
      import math

      import numpy as np
      from gnuradio import gr


      C_M_S = 299792458.0


      class blk(gr.sync_block):
          """Stage 6 baseline geometry and predicted geometric quantities."""

          def __init__(
              self,
              site_lat_deg=-32.724,
              baseline_e_m=-5.785,
              baseline_n_m=0.095,
              baseline_u_m=0.580,
              sky_cf=4.800e9,
          ):
              self.site_lat_deg = float(site_lat_deg)
              self.baseline_e_m = float(baseline_e_m)
              self.baseline_n_m = float(baseline_n_m)
              self.baseline_u_m = float(baseline_u_m)
              self.sky_cf = float(sky_cf)
              self._last_utc_hour = None
              self._last_tau_s = None
              self._last_fringe_hz = np.nan
              self._last_period_s = np.nan
              gr.sync_block.__init__(
                  self,
                  name='Baseline Geometry Engine',
                  in_sig=[np.float32, np.float32, np.float32],
                  out_sig=[
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                  ],
              )

          def set_site_lat_deg(self, value):
              self.site_lat_deg = float(value)

          def set_baseline_e_m(self, value):
              self.baseline_e_m = float(value)

          def set_baseline_n_m(self, value):
              self.baseline_n_m = float(value)

          def set_baseline_u_m(self, value):
              self.baseline_u_m = float(value)

          def set_sky_cf(self, value):
              self.sky_cf = float(value)

          @staticmethod
          def _wrap_deg_pm180(angle_deg):
              return ((angle_deg + 180.0) % 360.0) - 180.0

          @staticmethod
          def _delta_utc_seconds(utc_hour, prev_utc_hour):
              delta_h = utc_hour - prev_utc_hour
              if delta_h <= -12.0:
                  delta_h += 24.0
              elif delta_h > 12.0:
                  delta_h -= 24.0
              return delta_h * 3600.0

          def _compute_geometry(self, utc_hour, ha_hour, apparent_dec_deg):
              site_lat_deg = float(self.site_lat_deg)
              baseline = np.array(
                  [
                      float(self.baseline_e_m),
                      float(self.baseline_n_m),
                      float(self.baseline_u_m),
                  ],
                  dtype=np.float64,
              )
              sky_cf = float(self.sky_cf)

              phi = math.radians(site_lat_deg)
              h = math.radians(float(ha_hour) * 15.0)
              dec = math.radians(float(apparent_dec_deg))

              u_hat = np.array(
                  [
                      math.cos(h),
                      -math.sin(phi) * math.sin(h),
                      math.cos(phi) * math.sin(h),
                  ],
                  dtype=np.float64,
              )
              v_hat = np.array(
                  [
                      math.sin(dec) * math.sin(h),
                      math.cos(phi) * math.cos(dec)
                      + math.sin(phi) * math.sin(dec) * math.cos(h),
                      math.sin(phi) * math.cos(dec)
                      - math.cos(phi) * math.sin(dec) * math.cos(h),
                  ],
                  dtype=np.float64,
              )
              w_hat = np.array(
                  [
                      -math.cos(dec) * math.sin(h),
                      math.sin(dec) * math.cos(phi)
                      - math.cos(dec) * math.cos(h) * math.sin(phi),
                      math.sin(dec) * math.sin(phi)
                      + math.cos(dec) * math.cos(h) * math.cos(phi),
                  ],
                  dtype=np.float64,
              )

              u_m = float(np.dot(baseline, u_hat))
              v_m = float(np.dot(baseline, v_hat))
              w_m = float(np.dot(baseline, w_hat))
              tau_s = w_m / C_M_S
              tau_ns = tau_s * 1e9
              arrival_delay_10_ns = -tau_ns
              phase_deg = self._wrap_deg_pm180(360.0 * sky_cf * tau_s)

              fringe_hz = self._last_fringe_hz
              period_s = self._last_period_s
              if self._last_utc_hour is not None and self._last_tau_s is not None:
                  dt_s = self._delta_utc_seconds(float(utc_hour), self._last_utc_hour)
                  if dt_s > 1e-6:
                      fringe_hz = sky_cf * (tau_s - self._last_tau_s) / dt_s
                      if abs(fringe_hz) > 1e-12:
                          period_s = 1.0 / abs(fringe_hz)
                      else:
                          period_s = math.inf
                      self._last_fringe_hz = fringe_hz
                      self._last_period_s = period_s

              if self._last_utc_hour is None or abs(self._delta_utc_seconds(float(utc_hour), self._last_utc_hour)) > 1e-6:
                  self._last_utc_hour = float(utc_hour)
                  self._last_tau_s = tau_s

              return np.array(
                  [
                      u_m,
                      v_m,
                      w_m,
                      tau_ns,
                      arrival_delay_10_ns,
                      phase_deg,
                      fringe_hz,
                      period_s,
                  ],
                  dtype=np.float32,
              )

          def work(self, input_items, output_items):
              nout = len(input_items[0])
              for i in range(nout):
                  try:
                      values = self._compute_geometry(
                          float(input_items[0][i]),
                          float(input_items[1][i]),
                          float(input_items[2][i]),
                      )
                  except Exception as exc:
                      print(f"Stage 6 baseline geometry error: {exc}", flush=True)
                      values = np.full(8, np.nan, dtype=np.float32)

                  for out_idx, value in enumerate(values):
                      output_items[out_idx][i] = value

              return nout
    baseline_e_m: baseline_e_m
    baseline_n_m: baseline_n_m
    baseline_u_m: baseline_u_m
    comment: 'Stage 6 only: low-rate baseline geometry display after Stage 5 coordinates. Does not correct C01.'
    site_lat_deg: site_lat_deg
    sky_cf: sky_cf
  states: {}
- name: baseline_geometry_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    color2: ("blue", "red")
    color3: ("blue", "red")
    color4: ("blue", "red")
    color5: ("blue", "red")
    color6: ("blue", "red")
    color7: ("blue", "red")
    color8: ("blue", "red")
    comment: Stage 6 / Baseline Geometry numerical displays.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: u
    label2: v
    label3: w
    label4: Geometric Delay
    label5: RX1-RX0 Arrival
    label6: Geometric Phase
    label7: Fringe Rate
    label8: Fringe Period
    max: '100'
    min: '-100'
    name: '"Stage 6 / Baseline Geometry"'
    nconnections: '8'
    type: float
    unit1: m
    unit2: m
    unit3: m
    unit4: ns
    unit5: ns
    unit6: deg
    unit7: Hz
    unit8: s
    update_time: '0.5'
  states: {}
- name: auto_spectra_sink
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: 'RX0 P0: antenna 0 / 2.4 m'
    label2: 'RX1 P1: antenna 1 / 1.7 m'
    nconnections: '2'
    showports: 'True'
    vlen: fft_size
    x_axis_label: Sky frequency (GHz)
    x_start: sky_axis_start/1e9
    x_step: sky_axis_step/1e9
    y_axis_label: Relative power (dB)
  states: {}
- name: cross_accum
  id: blocks_integrate_xx
  parameters:
    decim: accum_frames
    type: complex
    vlen: fft_size
  states: {}
- name: cross_mag
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: cross_mag_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
    vlen: fft_size
  states: {}
- name: cross_mag_sink
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: '|C01|, X0 * conj(X1)'
    showports: 'True'
    vlen: fft_size
    x_axis_label: Sky frequency (GHz)
    x_start: sky_axis_start/1e9
    x_step: sky_axis_step/1e9
    y_axis_label: Relative cross magnitude (dB)
  states: {}
- name: cross_multiply_conjugate
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: fft_size
  states: {}
- name: cross_phase_deg
  id: blocks_multiply_const_vxx
  parameters:
    const: '[57.29577951308232]*fft_size'
    type: float
    vlen: fft_size
  states: {}
- name: cross_phase_rad
  id: blocks_complex_to_arg
  parameters:
    vlen: fft_size
  states: {}
- name: cross_phase_sink
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    label1: arg(C01), X0 * conj(X1)
    showports: 'True'
    vlen: fft_size
    x_axis_label: Sky frequency (GHz)
    x_start: sky_axis_start/1e9
    x_step: sky_axis_step/1e9
    y_axis_label: Cross phase (deg)
    ymax: '180'
    ymin: '-180'
  states: {}
- name: delay_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    comment: Stage 4 estimated differential delay from phase slope.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Differential Delay
    max: '100'
    min: '-100'
    name: '"Differential Delay (ns)"'
    type: float
    unit1: ns
    update_time: '0.25'
  states: {}
- name: phase_fit_rms_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    comment: Stage 4 RMS residual of linear phase fit.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Phase Fit RMS
    max: '180'
    min: '0'
    name: '"Phase Fit RMS (deg)"'
    type: float
    unit1: deg
    update_time: '0.25'
  states: {}
- name: phase_slope_delay_estimator
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Stage 4 phase-slope / differential-delay estimator.

          Fits unwrapped C01 phase against increasing B210 baseband/IF
          frequency. Cross-spectrum convention is C01 = X0 * conj(X1).
          Provisional sign convention: positive RX1 delay relative to RX0
          should produce positive phase slope versus increasing IF/baseband
          frequency and positive reported differential delay.
          """

          def __init__(self, fft_size=4096, samp_rate=30.72e6, phase_fit_edge_exclude_pct=7.5):
              self.fft_size = int(fft_size)
              self.samp_rate = float(samp_rate)
              self.phase_fit_edge_exclude_pct = float(phase_fit_edge_exclude_pct)
              gr.sync_block.__init__(
                  self,
                  name='Phase Slope / Delay Estimator',
                  in_sig=[(np.complex64, self.fft_size)],
                  out_sig=[np.float32, np.float32, np.float32],
              )
              self._f = (
                  (np.arange(self.fft_size, dtype=np.float64) - self.fft_size / 2.0)
                  * self.samp_rate
                  / self.fft_size
              )

          def set_phase_fit_edge_exclude_pct(self, value):
              self.phase_fit_edge_exclude_pct = float(value)

          def _fit_vectors(self, c01):
              edge_pct = float(self.phase_fit_edge_exclude_pct)
              if edge_pct < 0.0:
                  print(
                      f"Stage 4 phase fit warning: edge exclusion {edge_pct}% is below 0%; using 0%.",
                      flush=True,
                  )
                  edge_pct = 0.0
              elif edge_pct >= 50.0:
                  print(
                      f"Stage 4 phase fit warning: edge exclusion {edge_pct}% is >= 50%; using 49%.",
                      flush=True,
                  )
                  edge_pct = 49.0

              n_bins = len(c01)
              n_edge = int(n_bins * (edge_pct / 100.0))
              n_fit = n_bins - 2 * n_edge
              if n_fit < 2:
                  print(
                      f"Stage 4 phase fit warning: edge exclusion leaves {n_fit} bins; using full spectrum.",
                      flush=True,
                  )
                  n_edge = 0

              if n_edge > 0:
                  return c01[n_edge:-n_edge], self._f[n_edge:-n_edge]
              return c01, self._f

          def work(self, input_items, output_items):
              spectra = input_items[0]
              delay_ns = output_items[0]
              slope_deg_per_mhz = output_items[1]
              fit_rms_deg = output_items[2]

              for i, c01 in enumerate(spectra):
                  c01_fit, f_fit = self._fit_vectors(c01)
                  phase = np.angle(c01_fit)
                  phase_unwrapped = np.unwrap(phase).astype(np.float64)
                  slope, intercept = np.polyfit(f_fit, phase_unwrapped, 1)
                  phase_fit = slope * f_fit + intercept
                  residual = phase_unwrapped - phase_fit

                  delay_ns[i] = np.float32((slope / (2.0 * np.pi)) * 1e9)
                  slope_deg_per_mhz[i] = np.float32(slope * (180.0 / np.pi) * 1e6)
                  fit_rms_deg[i] = np.float32(
                      np.sqrt(np.mean(residual * residual)) * (180.0 / np.pi)
                  )

              return len(spectra)
    comment: 'Stage 4 only: low-rate estimator after cross_accum. Fits against increasing baseband/IF frequency, not displayed sky frequency.'
    fft_size: fft_size
    phase_fit_edge_exclude_pct: phase_fit_edge_exclude_pct
    samp_rate: samp_rate
  states: {}
- name: delay_slope_corrector
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Stage 7 frequency-domain delay-slope corrector.

          Input C01 uses the fixed convention C01 = X0 * conj(X1).
          Positive delay means RX1 is delayed relative to RX0 and produces a
          positive phase slope versus increasing B210 baseband/IF frequency.
          This block removes that slope using exp(-j*2*pi*f_bb*tau).
          The centre FFT bin is not rotated because f_bb[centre] = 0.
          """

          def __init__(
              self,
              fft_size=4096,
              samp_rate=30.72e6,
              instrument_delay_ns=0.0,
              delay_correction_enable=True,
          ):
              self.fft_size = int(fft_size)
              self.samp_rate = float(samp_rate)
              self.instrument_delay_ns = float(instrument_delay_ns)
              self.delay_correction_enable = self._as_bool(delay_correction_enable)
              gr.sync_block.__init__(
                  self,
                  name='Delay Slope Corrector',
                  in_sig=[(np.complex64, self.fft_size), np.float32],
                  out_sig=[(np.complex64, self.fft_size)],
              )
              self._f_bb = (
                  (np.arange(self.fft_size, dtype=np.float64) - self.fft_size / 2.0)
                  * self.samp_rate
                  / self.fft_size
              )

          @staticmethod
          def _as_bool(value):
              if isinstance(value, str):
                  return value.strip().lower() in ("1", "true", "yes", "on", "enable", "enabled")
              return bool(value)

          def set_instrument_delay_ns(self, value):
              self.instrument_delay_ns = float(value)

          def set_delay_correction_enable(self, value):
              self.delay_correction_enable = self._as_bool(value)

          def work(self, input_items, output_items):
              spectra = input_items[0]
              geo_arrival_ns = input_items[1]
              corrected = output_items[0]
              nout = len(spectra)

              if not self.delay_correction_enable:
                  corrected[:nout] = spectra
                  return nout

              instrument_delay_ns = float(self.instrument_delay_ns)
              if not np.isfinite(instrument_delay_ns):
                  corrected[:nout] = spectra
                  return nout

              for i in range(nout):
                  tau_geo_ns = float(geo_arrival_ns[i])
                  if not np.isfinite(tau_geo_ns):
                      corrected[i] = spectra[i]
                      continue

                  tau_apply_s = (tau_geo_ns + instrument_delay_ns) * 1e-9
                  rotation = np.exp((-1j * 2.0 * np.pi * self._f_bb * tau_apply_s)).astype(np.complex64)
                  corrected[i] = spectra[i] * rotation

              return nout
    comment: 'Stage 7 only: low-rate frequency-domain delay-slope correction after cross_accum. Does not fringe-stop centre frequency.'
    delay_correction_enable: delay_correction_enable
    fft_size: fft_size
    instrument_delay_ns: instrument_delay_ns
    samp_rate: samp_rate
  states: {}
- name: corrected_cross_phase_rad
  id: blocks_complex_to_arg
  parameters:
    comment: Stage 7 corrected C01 phase, radians.
    vlen: fft_size
  states: {}
- name: corrected_cross_phase_deg
  id: blocks_multiply_const_vxx
  parameters:
    comment: Convert Stage 7 corrected C01 phase from radians to degrees.
    const: '[57.29577951308232]*fft_size'
    type: float
    vlen: fft_size
  states: {}
- name: corrected_cross_phase_sink
  id: qtgui_vector_sink_f
  parameters:
    comment: Stage 7 delay-corrected but unstopped cross phase display.
    grid: 'True'
    label1: arg(C01 corrected), delay-slope corrected only
    name: '"Stage 7 - Delay-Corrected Cross Phase"'
    showports: 'True'
    vlen: fft_size
    x_axis_label: Sky frequency (GHz)
    x_start: sky_axis_start/1e9
    x_step: sky_axis_step/1e9
    y_axis_label: Corrected cross phase (deg)
    ymax: '180'
    ymin: '-180'
  states: {}
- name: corrected_phase_slope_delay_estimator
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Stage 7 corrected phase-slope / differential-delay diagnostic.

          Fits unwrapped C01 phase against increasing B210 baseband/IF
          frequency. Cross-spectrum convention is C01 = X0 * conj(X1).
          Provisional sign convention: positive RX1 delay relative to RX0
          should produce positive phase slope versus increasing IF/baseband
          frequency and positive reported differential delay.
          """

          def __init__(self, fft_size=4096, samp_rate=30.72e6, phase_fit_edge_exclude_pct=7.5):
              self.fft_size = int(fft_size)
              self.samp_rate = float(samp_rate)
              self.phase_fit_edge_exclude_pct = float(phase_fit_edge_exclude_pct)
              gr.sync_block.__init__(
                  self,
                  name='Corrected Phase Slope / Delay Estimator',
                  in_sig=[(np.complex64, self.fft_size)],
                  out_sig=[np.float32, np.float32, np.float32],
              )
              self._f = (
                  (np.arange(self.fft_size, dtype=np.float64) - self.fft_size / 2.0)
                  * self.samp_rate
                  / self.fft_size
              )

          def set_phase_fit_edge_exclude_pct(self, value):
              self.phase_fit_edge_exclude_pct = float(value)

          def _fit_vectors(self, c01):
              edge_pct = float(self.phase_fit_edge_exclude_pct)
              if edge_pct < 0.0:
                  print(
                      f"Stage 4 phase fit warning: edge exclusion {edge_pct}% is below 0%; using 0%.",
                      flush=True,
                  )
                  edge_pct = 0.0
              elif edge_pct >= 50.0:
                  print(
                      f"Stage 4 phase fit warning: edge exclusion {edge_pct}% is >= 50%; using 49%.",
                      flush=True,
                  )
                  edge_pct = 49.0

              n_bins = len(c01)
              n_edge = int(n_bins * (edge_pct / 100.0))
              n_fit = n_bins - 2 * n_edge
              if n_fit < 2:
                  print(
                      f"Stage 4 phase fit warning: edge exclusion leaves {n_fit} bins; using full spectrum.",
                      flush=True,
                  )
                  n_edge = 0

              if n_edge > 0:
                  return c01[n_edge:-n_edge], self._f[n_edge:-n_edge]
              return c01, self._f

          def work(self, input_items, output_items):
              spectra = input_items[0]
              delay_ns = output_items[0]
              slope_deg_per_mhz = output_items[1]
              fit_rms_deg = output_items[2]

              for i, c01 in enumerate(spectra):
                  c01_fit, f_fit = self._fit_vectors(c01)
                  phase = np.angle(c01_fit)
                  phase_unwrapped = np.unwrap(phase).astype(np.float64)
                  slope, intercept = np.polyfit(f_fit, phase_unwrapped, 1)
                  phase_fit = slope * f_fit + intercept
                  residual = phase_unwrapped - phase_fit

                  delay_ns[i] = np.float32((slope / (2.0 * np.pi)) * 1e9)
                  slope_deg_per_mhz[i] = np.float32(slope * (180.0 / np.pi) * 1e6)
                  fit_rms_deg[i] = np.float32(
                      np.sqrt(np.mean(residual * residual)) * (180.0 / np.pi)
                  )

              return len(spectra)
    comment: Stage 7 corrected C01 diagnostic. Same fit convention and edge exclusion as raw Stage 4 estimator.
    fft_size: fft_size
    phase_fit_edge_exclude_pct: phase_fit_edge_exclude_pct
    samp_rate: samp_rate
  states: {}
- name: corrected_delay_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    comment: Stage 7 corrected differential delay from corrected C01 phase slope.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Corrected Differential Delay
    max: '100'
    min: '-100'
    name: '"Corrected Differential Delay (ns)"'
    type: float
    unit1: ns
    update_time: '0.25'
  states: {}
- name: corrected_phase_slope_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    comment: Stage 7 corrected phase slope in degrees per MHz.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Corrected Phase Slope
    max: '1000'
    min: '-1000'
    name: '"Corrected Phase Slope (deg/MHz)"'
    type: float
    unit1: deg/MHz
    update_time: '0.25'
  states: {}
- name: corrected_phase_fit_rms_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    comment: Stage 7 RMS residual of corrected C01 linear phase fit.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Corrected Phase Fit RMS
    max: '180'
    min: '0'
    name: '"Corrected Phase Fit RMS (deg)"'
    type: float
    unit1: deg
    update_time: '0.25'
  states: {}
- name: broadband_visibility_combiner
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Stage 8 broadband complex visibility combiner.

          Operates on Stage-7 delay-corrected C01 spectra and outputs one complex
          unstopped visibility per accumulated spectrum. The combiner performs a
          coherent complex mean over the retained FFT bins.
          """

          def __init__(self, fft_size=4096, visibility_edge_exclude_pct=20.0):
              self.fft_size = int(fft_size)
              self.visibility_edge_exclude_pct = float(visibility_edge_exclude_pct)
              gr.sync_block.__init__(
                  self,
                  name='Broadband Visibility Combiner',
                  in_sig=[(np.complex64, self.fft_size)],
                  out_sig=[np.complex64],
              )

          def set_visibility_edge_exclude_pct(self, value):
              self.visibility_edge_exclude_pct = float(value)

          def _fit_slice(self):
              edge_pct = float(self.visibility_edge_exclude_pct)
              if edge_pct < 0.0:
                  print(
                      f"Stage 8 visibility warning: edge exclusion {edge_pct}% is below 0%; using 0%.",
                      flush=True,
                  )
                  edge_pct = 0.0
              elif edge_pct >= 50.0:
                  print(
                      f"Stage 8 visibility warning: edge exclusion {edge_pct}% is >= 50%; using 49%.",
                      flush=True,
                  )
                  edge_pct = 49.0

              n_edge = int(self.fft_size * (edge_pct / 100.0))
              n_used = self.fft_size - 2 * n_edge
              if n_used < 2:
                  print(
                      f"Stage 8 visibility warning: edge exclusion leaves {n_used} bins; using full spectrum.",
                      flush=True,
                  )
                  n_edge = 0

              if n_edge > 0:
                  return slice(n_edge, self.fft_size - n_edge)
              return slice(None)

          def work(self, input_items, output_items):
              spectra = input_items[0]
              visibility = output_items[0]
              use_bins = self._fit_slice()

              for i, spectrum in enumerate(spectra):
                  visibility[i] = np.complex64(np.mean(spectrum[use_bins], dtype=np.complex128))

              return len(spectra)
    comment: 'Stage 8 only: coherent complex mean over usable Stage-7 corrected frequency bins. No temporal integration.'
    fft_size: fft_size
    visibility_edge_exclude_pct: visibility_edge_exclude_pct
  states: {}
- name: fringe_stop_corrector
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Stage 8 centre-frequency geometric fringe-stop corrector.

          Uses Stage-6 tau_g, not RX1-RX0 arrival delay. The default sign is
          exp(-j*2*pi*sky_cf*tau_g), matching the project geometric phase convention.
          """

          def __init__(self, sky_cf=4.800e9, fringe_stop_enable=True, fringe_stop_sign=-1):
              self.sky_cf = float(sky_cf)
              self.fringe_stop_enable = self._as_bool(fringe_stop_enable)
              self.fringe_stop_sign = int(fringe_stop_sign)
              gr.sync_block.__init__(
                  self,
                  name='Fringe Stop Corrector',
                  in_sig=[np.complex64, np.float32],
                  out_sig=[np.complex64],
              )

          @staticmethod
          def _as_bool(value):
              if isinstance(value, str):
                  return value.strip().lower() in ("1", "true", "yes", "on", "enable", "enabled")
              return bool(value)

          def set_sky_cf(self, value):
              self.sky_cf = float(value)

          def set_fringe_stop_enable(self, value):
              self.fringe_stop_enable = self._as_bool(value)

          def set_fringe_stop_sign(self, value):
              self.fringe_stop_sign = int(value)

          def work(self, input_items, output_items):
              unstopped = input_items[0]
              tau_g_ns = input_items[1]
              stopped = output_items[0]
              nout = len(unstopped)

              if not self.fringe_stop_enable:
                  stopped[:nout] = unstopped
                  return nout

              sky_cf = float(self.sky_cf)
              sign = int(self.fringe_stop_sign)
              if sign not in (-1, 1) or not np.isfinite(sky_cf):
                  stopped[:nout] = unstopped
                  return nout

              for i in range(nout):
                  tau_ns = float(tau_g_ns[i])
                  if not np.isfinite(tau_ns):
                      stopped[i] = unstopped[i]
                      continue

                  tau_s = tau_ns * 1e-9
                  rotation = np.exp(1j * sign * 2.0 * np.pi * sky_cf * tau_s)
                  stopped[i] = np.complex64(unstopped[i] * rotation)

              return nout
    comment: 'Stage 8 only: centre-frequency geometric fringe stopping using Stage-6 tau_g output 3.'
    fringe_stop_enable: fringe_stop_enable
    fringe_stop_sign: fringe_stop_sign
    sky_cf: sky_cf
  states: {}
- name: unstopped_complex_to_float
  id: blocks_complex_to_float
  parameters:
    comment: Stage 8 V_unstopped I/Q for time display.
  states: {}
- name: stopped_complex_to_float
  id: blocks_complex_to_float
  parameters:
    comment: Stage 8 V_stopped I/Q for time display.
  states: {}
- name: visibility_iq_time_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"blue"'
    color2: '"red"'
    color3: '"green"'
    color4: '"black"'
    comment: Stage 8 low-rate complex visibility I/Q comparison. Sample rate is visibility_rate, not RF sample rate.
    grid: 'True'
    label1: Unstopped I
    label2: Unstopped Q
    label3: Stopped I
    label4: Stopped Q
    name: '"Stage 8 - Visibility I/Q"'
    nconnections: '4'
    size: '1000'
    srate: visibility_rate
    type: float
    update_time: '0.25'
  states: {}
- name: unstopped_visibility_mag
  id: blocks_complex_to_mag
  parameters:
    comment: Stage 8 V_unstopped amplitude.
  states: {}
- name: stopped_visibility_mag
  id: blocks_complex_to_mag
  parameters:
    comment: Stage 8 V_stopped amplitude.
  states: {}
- name: unstopped_visibility_phase_rad
  id: blocks_complex_to_arg
  parameters:
    comment: Stage 8 V_unstopped phase, radians.
  states: {}
- name: stopped_visibility_phase_rad
  id: blocks_complex_to_arg
  parameters:
    comment: Stage 8 V_stopped phase, radians.
  states: {}
- name: unstopped_visibility_phase_deg
  id: blocks_multiply_const_vxx
  parameters:
    comment: Convert V_unstopped phase from radians to degrees.
    const: '57.29577951308232'
    type: float
  states: {}
- name: stopped_visibility_phase_deg
  id: blocks_multiply_const_vxx
  parameters:
    comment: Convert V_stopped phase from radians to degrees.
    const: '57.29577951308232'
    type: float
  states: {}
- name: visibility_phase_time_sink
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    comment: Stage 8 phase-versus-time commissioning display.
    grid: 'True'
    label1: Unstopped Phase
    label2: Stopped Phase
    name: '"Stage 8 - Visibility Phase"'
    nconnections: '2'
    size: '1000'
    srate: visibility_rate
    type: float
    update_time: '0.25'
    ylabel: Phase
    ymax: '180'
    ymin: '-180'
    yunit: deg
  states: {}
- name: visibility_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    color2: ("blue", "red")
    color3: ("blue", "red")
    color4: ("blue", "red")
    comment: Stage 8 scalar visibility amplitude and phase diagnostics.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Unstopped Amplitude
    label2: Unstopped Phase
    label3: Stopped Amplitude
    label4: Stopped Phase
    max: '180'
    min: '-180'
    name: '"Stage 8 / Visibility Scalars"'
    nconnections: '4'
    type: float
    unit2: deg
    unit4: deg
    update_time: '0.25'
  states: {}
- name: coherent_visibility_integrator
  id: epy_block
  parameters:
    _source_code: |
      import math
      import threading

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):
          """Stage 9 non-overlapping coherent visibility integrator.

          Consumes native Stage-8 V_stopped samples and emits one complex mean for
          each complete integration window. Runtime integration changes reset the
          partial window so samples from different integration lengths are not mixed.
          """

          def __init__(self, visibility_rate=10.0, integration_time_s=1.0):
              self.visibility_rate = float(visibility_rate)
              self.integration_time_s = float(integration_time_s)
              self._lock = threading.RLock()
              self._window = []
              self._n_int = self._calc_n_int()
              self._warned_quantization = False
              gr.basic_block.__init__(
                  self,
                  name='Coherent Visibility Integrator',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.float32, np.float32, np.float32],
              )

          @staticmethod
          def _finite_complex(value):
              return np.isfinite(value.real) and np.isfinite(value.imag)

          @staticmethod
          def _nearest_int(value):
              return int(math.floor(float(value) + 0.5))

          def _calc_n_int(self):
              rate = float(self.visibility_rate)
              integ = float(self.integration_time_s)
              if not np.isfinite(rate) or rate <= 0.0:
                  rate = 1.0
              if not np.isfinite(integ) or integ <= 0.0:
                  integ = 0.1
              return max(1, self._nearest_int(integ * rate))

          def _effective_integration_s(self):
              rate = float(self.visibility_rate)
              if not np.isfinite(rate) or rate <= 0.0:
                  rate = 1.0
              return float(self._n_int) / rate

          def _reset_locked(self):
              self._window = []
              self._n_int = self._calc_n_int()
              self._warned_quantization = False

          def _warn_quantization_locked(self):
              requested = float(self.integration_time_s)
              effective = self._effective_integration_s()
              if (
                  not self._warned_quantization
                  and np.isfinite(requested)
                  and abs(requested - effective) > 1e-6
              ):
                  print(
                      f"Stage 9 integration warning: requested {requested:.6g} s, effective {effective:.6g} s "
                      f"from {self._n_int} native visibility samples.",
                      flush=True,
                  )
                  self._warned_quantization = True

          def set_visibility_rate(self, value):
              with self._lock:
                  self.visibility_rate = float(value)
                  self._reset_locked()

          def set_integration_time_s(self, value):
              with self._lock:
                  self.integration_time_s = float(value)
                  self._reset_locked()

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          def general_work(self, input_items, output_items):
              samples = input_items[0]
              vis_out = output_items[0]
              coherence_out = output_items[1]
              effective_out = output_items[2]
              n_int_out = output_items[3]

              produced = 0
              consumed = 0
              out_capacity = len(vis_out)

              with self._lock:
                  n_int = self._calc_n_int()
                  if n_int != self._n_int:
                      self._reset_locked()
                      n_int = self._n_int
                  self._warn_quantization_locked()

                  for sample in samples:
                      if produced >= out_capacity:
                          break

                      consumed += 1
                      if not self._finite_complex(sample):
                          self._window = []
                          continue

                      self._window.append(np.complex64(sample))
                      if len(self._window) < n_int:
                          continue

                      window = np.asarray(self._window, dtype=np.complex64)
                      total = np.sum(window, dtype=np.complex128)
                      denom = np.sum(np.abs(window), dtype=np.float64)
                      coherence = 100.0 * abs(total) / denom if denom > 0.0 else np.nan

                      vis_out[produced] = np.complex64(total / n_int)
                      coherence_out[produced] = np.float32(coherence)
                      effective_out[produced] = np.float32(self._effective_integration_s())
                      n_int_out[produced] = np.float32(n_int)
                      produced += 1
                      self._window = []

              self.consume(0, consumed)
              return produced
    comment: 'Stage 9 only: variable-rate non-overlapping coherent integration of native Stage-8 V_stopped.'
    integration_time_s: integration_time_s
    visibility_rate: visibility_rate
  states: {}
- name: phase_stability_advisor
  id: epy_block
  parameters:
    _source_code: |
      import math
      import threading

      import numpy as np
      from gnuradio import gr


      MAX_INTEGRATION_S = 60.0


      class blk(gr.sync_block):
          """Stage 9 residual phase-rate and coherence advisor.

          Measures native Stage-8 V_stopped phase history. Outputs are advisory only
          and must not control integration time, fringe-stop sign, geometry, or
          antenna tracking.
          """

          def __init__(
              self,
              visibility_rate=10.0,
              integration_time_s=1.0,
              phase_rate_fit_window_s=60.0,
              coherence_target_pct=95.0,
          ):
              self.visibility_rate = float(visibility_rate)
              self.integration_time_s = float(integration_time_s)
              self.phase_rate_fit_window_s = float(phase_rate_fit_window_s)
              self.coherence_target_pct = float(coherence_target_pct)
              self._history = []
              self._warned_quantization = False
              self._lock = threading.RLock()
              gr.sync_block.__init__(
                  self,
                  name='Phase Stability Advisor',
                  in_sig=[np.complex64],
                  out_sig=[
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                  ],
              )

          @staticmethod
          def _finite_complex(value):
              return np.isfinite(value.real) and np.isfinite(value.imag)

          @staticmethod
          def _nearest_int(value):
              return int(math.floor(float(value) + 0.5))

          def _visibility_rate(self):
              rate = float(self.visibility_rate)
              return rate if np.isfinite(rate) and rate > 0.0 else 1.0

          def _n_int(self):
              integ = float(self.integration_time_s)
              if not np.isfinite(integ) or integ <= 0.0:
                  integ = 0.1
              return max(1, self._nearest_int(integ * self._visibility_rate()))

          def _effective_integration_s(self):
              return float(self._n_int()) / self._visibility_rate()

          def _history_len(self):
              fit_window = float(self.phase_rate_fit_window_s)
              if not np.isfinite(fit_window) or fit_window <= 0.0:
                  fit_window = 60.0
              return max(3, self._nearest_int(fit_window * self._visibility_rate()))

          def _coherence_for_rate(self, omega_rad_s, integration_s):
              x = abs(float(omega_rad_s) * float(integration_s) / 2.0)
              if x < 1e-9:
                  return 1.0
              return abs(math.sin(x) / x)

          def _solve_coherence_x(self, target_fraction):
              target = min(max(float(target_fraction), 1e-6), 0.999999)
              lo = 0.0
              hi = math.pi
              for _ in range(80):
                  mid = 0.5 * (lo + hi)
                  value = math.sin(mid) / mid if mid != 0.0 else 1.0
                  if value > target:
                      lo = mid
                  else:
                      hi = mid
              return 0.5 * (lo + hi)

          def _recommended_max_s(self, omega_rad_s):
              omega = abs(float(omega_rad_s))
              if omega < 1e-12:
                  return MAX_INTEGRATION_S
              target = float(self.coherence_target_pct) / 100.0
              x = self._solve_coherence_x(target)
              return min(MAX_INTEGRATION_S, 2.0 * x / omega)

          def set_visibility_rate(self, value):
              with self._lock:
                  self.visibility_rate = float(value)
                  self._history = []
                  self._warned_quantization = False

          def set_integration_time_s(self, value):
              with self._lock:
                  self.integration_time_s = float(value)
                  self._warned_quantization = False

          def set_phase_rate_fit_window_s(self, value):
              with self._lock:
                  self.phase_rate_fit_window_s = float(value)
                  self._history = []

          def set_coherence_target_pct(self, value):
              with self._lock:
                  self.coherence_target_pct = float(value)

          def _estimate_locked(self):
              m = self._history_len()
              if len(self._history) < m:
                  return (np.nan, np.nan, np.nan, np.nan)

              values = np.asarray(self._history[-m:], dtype=np.complex64)
              phase = np.unwrap(np.angle(values)).astype(np.float64)
              t = np.arange(m, dtype=np.float64) / self._visibility_rate()
              t -= np.mean(t)
              omega, intercept = np.polyfit(t, phase, 1)
              residual = phase - (omega * t + intercept)
              rms_deg = np.sqrt(np.mean(residual * residual)) * 180.0 / np.pi
              rate_deg_s = omega * 180.0 / np.pi
              rate_coherence_pct = 100.0 * self._coherence_for_rate(omega, self._effective_integration_s())
              recommended_s = self._recommended_max_s(omega)
              return (rate_deg_s, rms_deg, rate_coherence_pct, recommended_s)

          def _warn_quantization_locked(self):
              requested = float(self.integration_time_s)
              effective = self._effective_integration_s()
              if (
                  not self._warned_quantization
                  and np.isfinite(requested)
                  and abs(requested - effective) > 1e-6
              ):
                  print(
                      f"Stage 9 advisor warning: requested {requested:.6g} s, effective {effective:.6g} s "
                      f"from {self._n_int()} native visibility samples.",
                      flush=True,
                  )
                  self._warned_quantization = True

          def work(self, input_items, output_items):
              samples = input_items[0]
              rate_out = output_items[0]
              rms_out = output_items[1]
              rate_coherence_out = output_items[2]
              recommended_out = output_items[3]
              requested_out = output_items[4]
              effective_out = output_items[5]
              n_int_out = output_items[6]

              with self._lock:
                  self._warn_quantization_locked()
                  for i, sample in enumerate(samples):
                      if self._finite_complex(sample) and abs(sample) > 0.0:
                          self._history.append(np.complex64(sample))
                          m = self._history_len()
                          if len(self._history) > m:
                              self._history = self._history[-m:]
                      else:
                          self._history = []

                      rate_deg_s, rms_deg, rate_coherence_pct, recommended_s = self._estimate_locked()
                      rate_out[i] = np.float32(rate_deg_s)
                      rms_out[i] = np.float32(rms_deg)
                      rate_coherence_out[i] = np.float32(rate_coherence_pct)
                      recommended_out[i] = np.float32(recommended_s)
                      requested_out[i] = np.float32(self.integration_time_s)
                      effective_out[i] = np.float32(self._effective_integration_s())
                      n_int_out[i] = np.float32(self._n_int())

              return len(samples)
    coherence_target_pct: coherence_target_pct
    comment: Stage 9 advisory-only residual native stopped-phase rate and coherence estimates.
    integration_time_s: integration_time_s
    phase_rate_fit_window_s: phase_rate_fit_window_s
    visibility_rate: visibility_rate
  states: {}
- name: phase_stability_effective_integration_null
  id: blocks_null_sink
  parameters:
    comment: Terminate duplicate Stage 9 advisor effective-integration output; coherent integrator already displays this value.
    type: float
  states: {}
- name: phase_stability_n_int_null
  id: blocks_null_sink
  parameters:
    comment: Terminate duplicate Stage 9 advisor integration-sample-count output; coherent integrator already displays this value.
    type: float
  states: {}
- name: integrated_visibility_mag
  id: blocks_complex_to_mag
  parameters:
    comment: Stage 9 integrated V_stopped amplitude.
  states: {}
- name: integrated_visibility_phase_rad
  id: blocks_complex_to_arg
  parameters:
    comment: Stage 9 integrated V_stopped phase, radians.
  states: {}
- name: integrated_visibility_phase_deg
  id: blocks_multiply_const_vxx
  parameters:
    comment: Convert integrated V_stopped phase from radians to degrees.
    const: '57.29577951308232'
    type: float
  states: {}
- name: stage9_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    color10: ("blue", "red")
    color2: ("blue", "red")
    color3: ("blue", "red")
    color4: ("blue", "red")
    color5: ("blue", "red")
    color6: ("blue", "red")
    color7: ("blue", "red")
    color8: ("blue", "red")
    color9: ("blue", "red")
    comment: Stage 9 coherent integration and phase-stability numerical diagnostics.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Requested Integration
    label10: Recommended Max Integration
    label2: Effective Integration
    label3: Integration Samples
    label4: Integrated Stopped Amplitude
    label5: Integrated Stopped Phase
    label6: Window Coherence Retained
    label7: Residual Phase Rate
    label8: Residual Phase Fit RMS
    label9: Rate-Based Coherence
    max: '100'
    min: '-100'
    name: '"Stage 9 / Integration + Stability"'
    nconnections: '10'
    type: float
    unit1: s
    unit10: s
    unit2: s
    unit3: samples
    unit5: deg
    unit6: '%'
    unit7: deg/s
    unit8: deg
    unit9: '%'
    update_time: '0.25'
  states: {}
- name: phase_slope_number_sink
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    comment: Stage 4 phase slope in degrees per MHz.
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Phase Slope
    max: '1000'
    min: '-1000'
    name: '"Phase Slope (deg/MHz)"'
    type: float
    unit1: deg/MHz
    update_time: '0.25'
  states: {}
- name: rx0_fft
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: rx0_mag2
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: rx0_power_accum
  id: blocks_integrate_xx
  parameters:
    decim: accum_frames
    type: float
    vlen: fft_size
  states: {}
- name: rx0_power_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: rx0_stream_to_vector
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: rx1_fft
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: rx1_mag2
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: rx1_power_accum
  id: blocks_integrate_xx
  parameters:
    decim: accum_frames
    type: float
    vlen: fft_size
  states: {}
- name: rx1_power_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: rx1_stream_to_vector
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    center_freq0: if_cf
    center_freq1: if_cf
    clock_rate: '0.0'
    clock_source0: external
    dev_addr: ''
    dev_args: '"num_recv_frames=256"'
    gain0: gain0
    gain1: gain1
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: sync
    time_source0: internal
    type: fc32
  states: {}

connections:
- [astronomy_coordinate_engine, '0', astronomy_number_sink, '0']
- [astronomy_coordinate_engine, '1', astronomy_number_sink, '1']
- [astronomy_coordinate_engine, '2', astronomy_number_sink, '2']
- [astronomy_coordinate_engine, '3', astronomy_number_sink, '3']
- [astronomy_coordinate_engine, '4', astronomy_number_sink, '4']
- [astronomy_coordinate_engine, '5', astronomy_number_sink, '5']
- [astronomy_coordinate_engine, '6', astronomy_number_sink, '6']
- [astronomy_coordinate_engine, '0', baseline_geometry_engine, '0']
- [astronomy_coordinate_engine, '2', baseline_geometry_engine, '1']
- [astronomy_coordinate_engine, '6', baseline_geometry_engine, '2']
- [baseline_geometry_engine, '0', baseline_geometry_number_sink, '0']
- [baseline_geometry_engine, '1', baseline_geometry_number_sink, '1']
- [baseline_geometry_engine, '2', baseline_geometry_number_sink, '2']
- [baseline_geometry_engine, '3', baseline_geometry_number_sink, '3']
- [baseline_geometry_engine, '4', baseline_geometry_number_sink, '4']
- [baseline_geometry_engine, '5', baseline_geometry_number_sink, '5']
- [baseline_geometry_engine, '6', baseline_geometry_number_sink, '6']
- [baseline_geometry_engine, '7', baseline_geometry_number_sink, '7']
- [baseline_geometry_engine, '4', delay_slope_corrector, '1']
- [corrected_cross_phase_deg, '0', corrected_cross_phase_sink, '0']
- [corrected_cross_phase_rad, '0', corrected_cross_phase_deg, '0']
- [corrected_phase_slope_delay_estimator, '0', corrected_delay_number_sink, '0']
- [corrected_phase_slope_delay_estimator, '1', corrected_phase_slope_number_sink, '0']
- [corrected_phase_slope_delay_estimator, '2', corrected_phase_fit_rms_number_sink, '0']
- [cross_accum, '0', astronomy_coordinate_engine, '0']
- [baseline_geometry_engine, '3', fringe_stop_corrector, '1']
- [broadband_visibility_combiner, '0', fringe_stop_corrector, '0']
- [broadband_visibility_combiner, '0', unstopped_complex_to_float, '0']
- [broadband_visibility_combiner, '0', unstopped_visibility_mag, '0']
- [broadband_visibility_combiner, '0', unstopped_visibility_phase_rad, '0']
- [cross_accum, '0', delay_slope_corrector, '0']
- [delay_slope_corrector, '0', broadband_visibility_combiner, '0']
- [delay_slope_corrector, '0', corrected_cross_phase_rad, '0']
- [delay_slope_corrector, '0', corrected_phase_slope_delay_estimator, '0']
- [cross_accum, '0', cross_mag, '0']
- [cross_accum, '0', cross_phase_rad, '0']
- [cross_accum, '0', phase_slope_delay_estimator, '0']
- [cross_mag, '0', cross_mag_db, '0']
- [cross_mag_db, '0', cross_mag_sink, '0']
- [cross_multiply_conjugate, '0', cross_accum, '0']
- [cross_phase_deg, '0', cross_phase_sink, '0']
- [cross_phase_rad, '0', cross_phase_deg, '0']
- [coherent_visibility_integrator, '0', integrated_visibility_mag, '0']
- [coherent_visibility_integrator, '0', integrated_visibility_phase_rad, '0']
- [coherent_visibility_integrator, '1', stage9_number_sink, '5']
- [coherent_visibility_integrator, '2', stage9_number_sink, '1']
- [coherent_visibility_integrator, '3', stage9_number_sink, '2']
- [fringe_stop_corrector, '0', coherent_visibility_integrator, '0']
- [fringe_stop_corrector, '0', phase_stability_advisor, '0']
- [fringe_stop_corrector, '0', stopped_complex_to_float, '0']
- [fringe_stop_corrector, '0', stopped_visibility_mag, '0']
- [fringe_stop_corrector, '0', stopped_visibility_phase_rad, '0']
- [stopped_complex_to_float, '0', visibility_iq_time_sink, '2']
- [stopped_complex_to_float, '1', visibility_iq_time_sink, '3']
- [stopped_visibility_mag, '0', visibility_number_sink, '2']
- [stopped_visibility_phase_deg, '0', visibility_number_sink, '3']
- [stopped_visibility_phase_deg, '0', visibility_phase_time_sink, '1']
- [stopped_visibility_phase_rad, '0', stopped_visibility_phase_deg, '0']
- [unstopped_complex_to_float, '0', visibility_iq_time_sink, '0']
- [unstopped_complex_to_float, '1', visibility_iq_time_sink, '1']
- [unstopped_visibility_mag, '0', visibility_number_sink, '0']
- [unstopped_visibility_phase_deg, '0', visibility_number_sink, '1']
- [unstopped_visibility_phase_deg, '0', visibility_phase_time_sink, '0']
- [unstopped_visibility_phase_rad, '0', unstopped_visibility_phase_deg, '0']
- [integrated_visibility_mag, '0', stage9_number_sink, '3']
- [integrated_visibility_phase_deg, '0', stage9_number_sink, '4']
- [integrated_visibility_phase_rad, '0', integrated_visibility_phase_deg, '0']
- [phase_stability_advisor, '0', stage9_number_sink, '6']
- [phase_stability_advisor, '1', stage9_number_sink, '7']
- [phase_stability_advisor, '2', stage9_number_sink, '8']
- [phase_stability_advisor, '3', stage9_number_sink, '9']
- [phase_stability_advisor, '4', stage9_number_sink, '0']
- [phase_stability_advisor, '5', phase_stability_effective_integration_null, '0']
- [phase_stability_advisor, '6', phase_stability_n_int_null, '0']
- [phase_slope_delay_estimator, '0', delay_number_sink, '0']
- [phase_slope_delay_estimator, '1', phase_slope_number_sink, '0']
- [phase_slope_delay_estimator, '2', phase_fit_rms_number_sink, '0']
- [rx0_fft, '0', cross_multiply_conjugate, '0']
- [rx0_fft, '0', rx0_mag2, '0']
- [rx0_mag2, '0', rx0_power_accum, '0']
- [rx0_power_accum, '0', rx0_power_db, '0']
- [rx0_power_db, '0', auto_spectra_sink, '0']
- [rx0_stream_to_vector, '0', rx0_fft, '0']
- [rx1_fft, '0', cross_multiply_conjugate, '1']
- [rx1_fft, '0', rx1_mag2, '0']
- [rx1_mag2, '0', rx1_power_accum, '0']
- [rx1_power_accum, '0', rx1_power_db, '0']
- [rx1_power_db, '0', auto_spectra_sink, '1']
- [rx1_stream_to_vector, '0', rx1_fft, '0']
- [uhd_usrp_source_0, '0', rx0_stream_to_vector, '0']
- [uhd_usrp_source_0, '1', rx1_stream_to_vector, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
